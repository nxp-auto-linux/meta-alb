SRCREV_glibc = "c84018a05aec80f5ee6f682db0da1130b0196aef"

SRC_URI:remove = "file://CVE-2023-0687.patch"
