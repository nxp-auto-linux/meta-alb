FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

require qemu-patches.inc
