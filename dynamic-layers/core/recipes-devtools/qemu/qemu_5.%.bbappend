FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

require qemu-patches.inc
