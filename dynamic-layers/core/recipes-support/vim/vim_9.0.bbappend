PACKAGECONFIG:remove:s32cc = "x11 gtkgui"
