DEPENDS_remove = "gobject-introspection-stub"

DEPENDS += "gobject-introspection"
