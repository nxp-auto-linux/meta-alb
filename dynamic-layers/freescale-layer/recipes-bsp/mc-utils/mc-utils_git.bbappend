# Missing part family compatibility defines
MC_CFG:ls2080a = "ls2080a"
MC_CFG:ls2084a = "ls2088a"
