# The original recipe is missing this dependency.
# dtc is required for mkimage to do its work properly.
DEPENDS += "dtc"