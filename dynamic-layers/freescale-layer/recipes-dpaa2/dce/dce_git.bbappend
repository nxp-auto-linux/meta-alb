COMPATIBLE_MACHINE += "(ls2084a)"
