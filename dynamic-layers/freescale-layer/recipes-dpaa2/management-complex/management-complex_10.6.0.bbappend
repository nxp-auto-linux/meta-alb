COMPATIBLE_MACHINE += "|(ls2080a|ls2084a)"
