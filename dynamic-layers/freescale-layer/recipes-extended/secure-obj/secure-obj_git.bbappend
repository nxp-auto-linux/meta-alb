
DEPENDS:remove = "python3-pycrypto-native"
DEPENDS += "python3-pycryptodome-native"
