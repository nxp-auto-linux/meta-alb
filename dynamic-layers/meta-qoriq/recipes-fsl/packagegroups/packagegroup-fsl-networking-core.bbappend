RDEPENDS_${PN}_append = " \
    netcat \
"

