COMPATIBLE_MACHINE:append = "|(s32g274abluebox3)"
