DEPENDS += "dbus-glib-native"
