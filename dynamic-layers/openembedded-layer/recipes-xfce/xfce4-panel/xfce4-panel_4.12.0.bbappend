inherit distro_features_check

REQUIRED_DISTRO_FEATURES = "x11"
