
IMAGE_FSTYPES_remove = "ext2.gz.u-boot jffs2 ubi"