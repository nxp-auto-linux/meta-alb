RDEPENDS_${PN}_append_ls2080a = " \
    dpdk \
    odp \
"
RDEPENDS_${PN}_remove_ls2084a = "aiopsl"
