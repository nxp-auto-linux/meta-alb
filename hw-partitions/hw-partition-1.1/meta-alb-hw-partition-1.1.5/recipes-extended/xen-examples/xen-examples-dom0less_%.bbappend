require xen-examples-hw-partition.inc

addtask post_unpack_hw_partition after do_post_unpack before do_patch
