FILESEXTRAPATHS:prepend := "${THISDIR}/xen:"

SRC_URI:append:s32n = " file://xen-hw-partition-1.1.5.cfg"
