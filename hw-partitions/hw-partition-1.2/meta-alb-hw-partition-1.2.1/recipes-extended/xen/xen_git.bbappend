FILESEXTRAPATHS:prepend := "${THISDIR}/xen:"

SRC_URI:append:s32n = " file://xen-hw-partition-1.2.1.cfg"
