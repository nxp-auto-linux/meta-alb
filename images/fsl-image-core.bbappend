# To support SSD deployment
IMAGE_FSTYPES += "tar.gz"