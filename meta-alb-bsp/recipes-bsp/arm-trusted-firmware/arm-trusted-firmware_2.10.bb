# Copyright 2024 NXP

PV = "2.10.33"

require recipes-bsp/arm-trusted-firmware/atf-src.inc
require recipes-bsp/arm-trusted-firmware/arm-trusted-firmware.inc
