require recipes-extended/xen-examples/xen-examples.inc

CFG_NAME:s32cc = "config_s32cc_default"
