PACKAGECONFIG:remove:s32 = "x11 gtkgui"
