SRC_URI = "ftp://ftp.netbsd.org/pub/pkgsrc/distfiles/${BP}.tar.gz \
            file://iperf-2.0.5_ManPage.patch \
            file://0001-fix-out-of-tree-config.patch \
          "
