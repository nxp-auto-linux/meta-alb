# Copyright 2021 NXP

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "\
	file://0001-lmbench-update-getsummary-search-pattern-to-be-more-.patch \
"
