SRC_URI = "${SOURCEFORGE_MIRROR}/expat/expat-${PV}-RENAMED-VULNERABLE-PLEASE-USE-2.4.1-INSTEAD.tar.bz2 \
           file://libtool-tag.patch \
           file://run-ptest \
           file://0001-Add-output-of-tests-result.patch \
          "
