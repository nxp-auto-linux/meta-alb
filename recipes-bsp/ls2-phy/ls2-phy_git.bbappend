# Ensure the BlueBoxes are included
COMPATIBLE_MACHINE:append = "|(ls2080abluebox|ls2084abluebox)"
