PPA_PATH_ls2084a = "ls2088"
COMPATIBLE_MACHINE_append = "|(ls2080abluebox|ls2084abluebox|ls2084abbmini)"
