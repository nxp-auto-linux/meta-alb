# For CA.pl and tsget
PACKAGECONFIG_append = " perl"
