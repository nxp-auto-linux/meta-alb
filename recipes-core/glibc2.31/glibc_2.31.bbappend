
SRC_URI += " \
    file://0001-Fix-GCC-11-Warray-parameter-warning-for-__sigsetjmp-.patch \
    file://0002-Avoid-Wstringop-overflow-warning-in-pthread_cleanup_.patch \
    file://0003-Disable-spurious-Wstringop-overflow-for-setjmp-longj.patch \
    file://0004-glibc2.31-Quick-fix-for-gcc-11-array-bounds-error.patch \
    file://0005-glibc2.31-gcc-11-declaration-hack.patch \
    file://0006-glibc2.31-Fixed-what-appears-to-be-a-genuine-declara.patch \
    file://0007-glibc2.31-gcc-11-array-bounds-hack.patch \
"
