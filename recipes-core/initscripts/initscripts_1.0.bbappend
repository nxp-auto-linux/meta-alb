# Copyright 2022 NXP

FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
SRC_URI += "\
    file://volatiles \
"
