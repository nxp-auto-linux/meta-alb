SRC_URI = "https://ftp.osuosl.org/pub/blfs/conglomeration/libjpeg-turbo/${BPN}-${BASEPV}.tar.gz"
