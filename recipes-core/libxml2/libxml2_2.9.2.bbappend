#
# We enable the python bindings on this recipe
# TBD if this is still necessary
#EXTRA_OECONF = "--with-python --without-debug --without-legacy --with-catalog --without-docbook --with-c14n --without-lzma --with-fexceptions"
