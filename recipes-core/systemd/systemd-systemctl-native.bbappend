FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += "file://0001-systemctl-do-not-exit-on-errors.diff"
