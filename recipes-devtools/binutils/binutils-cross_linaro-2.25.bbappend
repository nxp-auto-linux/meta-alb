EXTRA_OECONF += " --disable-gdb "
