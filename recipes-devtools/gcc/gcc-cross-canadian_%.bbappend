EXTRA_INCLUDE_FILE = "gcc-cross-canadian-fsl.inc"

include gcc-${PV}-fsl.inc
