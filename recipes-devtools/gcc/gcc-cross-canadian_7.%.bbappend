EXTRA_INCLUDE_FILE = "gcc-cross-canadian-fsl.inc"

require gcc-${PV}-fsl.inc
