require gcc-${PV}-fsl.inc