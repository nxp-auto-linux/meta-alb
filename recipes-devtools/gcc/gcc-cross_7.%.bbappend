EXTRA_INCLUDE_FILE = "gcc-cross-fsl.inc"

require gcc-${PV}-fsl.inc
