require gcc-${PV}-fsl.inc

DEPENDS += "isl"
