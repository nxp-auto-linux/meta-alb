INSANE_SKIP_${PN} += "ldflags"
