SRC_URI = "https://ftp.osuosl.org/pub/blfs/conglomeration/giflib/${BP}.tar.bz2"
