# Enable building C++ compiler
EXTRA_OECONF:remove = "--disable-cxx"