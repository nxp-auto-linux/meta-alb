# Enable building C++ compiler
EXTRA_OECONF_remove = "--disable-cxx"