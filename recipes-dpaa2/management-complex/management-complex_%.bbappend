
COMPATIBLE_MACHINE_append = "|(ls2084a)|(ls2084abluebox|ls2084abbmini)"
