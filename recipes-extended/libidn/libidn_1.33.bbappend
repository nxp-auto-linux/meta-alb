#Choose GPL licensing version explicitly

LICENSE = "LGPLv3 & GPLv3+"
LICENSE_${PN} = "LGPLv3"
