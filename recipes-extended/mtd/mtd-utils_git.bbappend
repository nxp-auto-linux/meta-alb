FILESEXTRAPATHS:prepend := "${THISDIR}/mtd-utils:"
SRC_URI:append:gen1 = " file://0001-mtd-utils-flash_erase-Add-flash-erase-chip.patch"
