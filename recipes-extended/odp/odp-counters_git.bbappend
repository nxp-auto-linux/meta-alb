COMPATIBLE_MACHINE_append = "|(ls2084a)"
