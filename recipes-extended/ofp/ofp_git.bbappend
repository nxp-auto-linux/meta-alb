# There is nothing architecture specific here
COMPATIBLE_MACHINE = ""
