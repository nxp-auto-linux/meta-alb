FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-canfdtest-Relax-the-order-of-incoming-messages.patch"

SRCREV = "cfe41963f3425e9adb01a70cfaddedf5e5982720"
PV = "2023.03"
