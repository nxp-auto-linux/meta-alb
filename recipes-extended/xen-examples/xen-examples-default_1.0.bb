require recipes-extended/xen-examples/xen-examples.inc

CFG_NAME = "config_s32_default"

SRC_URI = "file://config_s32_default"
