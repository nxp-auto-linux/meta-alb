require xen-nxp.inc
