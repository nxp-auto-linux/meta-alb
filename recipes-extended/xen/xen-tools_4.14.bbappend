require xen-nxp.inc

FILES:${PN}-scripts-common += " ${sysconfdir}/xen/*.cfg"
