#
# Copyright 2018 NXP
# Generic recipe to create a boot flash image

require recipes-fsl/images/fsl-image-flash.bb
