require fsl-image-bluebox.bb

require fsl-image-blueboxadditionsdt.inc
