RDEPENDS_${PN}_append_ls2 += " \
    python \
    python-misc \
    python-modules \
"
