RDEPENDS_${PN}_remove_s32v234pcie = " \
    ipsec-demo \
"
RDEPENDS_${PN}_remove_s32v234pciebcm = " \
    ipsec-demo \
"
RDEPENDS_${PN}_remove_s32v234evb = " \
    ipsec-demo \
"
RDEPENDS_${PN}_remove_s32v234evbbcm = " \
    ipsec-demo \
"
RDEPENDS_${PN}_remove_s32v234bbmini = " \
    ipsec-demo \
"

RDEPENDS_${PN}_append = " \
    netcat \
"

