
# optee-os-* were not in COMPATIBLE_MACHINE for ls2 targets
# do not add it now (optee-os-qoriq does not even build for ls2084a*)
SECURE_TOOLS:ls2 = ""
