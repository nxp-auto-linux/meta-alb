# Copyright (C) 2013 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)
# Copyright 2017 NXP

require gpu-viv-bin-s32v2xx.inc

SRC_URI[md5sum] = "aa0fd134249c113daf977e2300ea4394"

PROVIDES = "virtual/libgles1 virtual/libgles2 virtual/egl"
