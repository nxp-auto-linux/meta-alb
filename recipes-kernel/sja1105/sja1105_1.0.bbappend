FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += "\
    file://0001-sja1105-module-Makefile-didn-t-respect-install-dirs.patch \
"
