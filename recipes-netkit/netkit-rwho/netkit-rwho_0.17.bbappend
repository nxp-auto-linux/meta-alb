SRC_URI = "http://ftp.debian.org/debian//pool/main/n/netkit-rwho/netkit-rwho_${PV}.orig.tar.gz;name=archive \
           http://ftp.debian.org/debian//pool/main/n/netkit-rwho/netkit-rwho_${PV}-13.debian.tar.gz;name=patch13 \
           file://rwhod \
           file://rwhod.default \
"
