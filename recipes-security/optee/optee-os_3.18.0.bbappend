require optee-os-nxp.inc