require optee-nxp.inc