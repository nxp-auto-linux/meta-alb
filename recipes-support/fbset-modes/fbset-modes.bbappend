# Include fb.modes setting for S32V234

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI = "file://fb.modes"

S = "${WORKDIR}"
