SRC_URI = "https://ftp.osuosl.org/pub/blfs/7.6/l/lcms2-${PV}.tar.gz"
