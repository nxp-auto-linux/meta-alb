#Choose GPL licensing version explicitly

LICENSE = "LGPLv3+"
