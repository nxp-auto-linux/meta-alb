# Original link for download lm-sensors is dead now, update with new site

SRC_URI = "http://sources.openembedded.org/lm_sensors-${PV}.tar.bz2 \
           file://fancontrol.init \
           file://sensord.init \
           file://sensord.service \
"
