# Original link for download netperf is dead now, update with new site

SRC_URI="ftp://ftp.netbsd.org/pub/pkgsrc/distfiles/netperf-${PV}.tar.bz2 \
         file://cpu_set.patch \
         file://vfork.patch \
         file://init"

